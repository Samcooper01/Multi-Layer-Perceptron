mp20 net61 b vdd! vdd! pmos_rvt w=243e-9 l=20e-9 nfin=9
mp19 net62 a net61 vdd! pmos_rvt w=243e-9 l=20e-9 nfin=9
mp18 s cin net62 vdd! pmos_rvt w=243e-9 l=20e-9 nfin=9
mp13 s cout net41 vdd! pmos_rvt w=162e-9 l=20e-9 nfin=6
mp12 net41 cin vdd! vdd! pmos_rvt w=162e-9 l=20e-9 nfin=6
mp11 net41 b vdd! vdd! pmos_rvt w=162e-9 l=20e-9 nfin=6
mp10 net41 a vdd! vdd! pmos_rvt w=162e-9 l=20e-9 nfin=6
mp5 net19 b vdd! vdd! pmos_rvt w=162e-9 l=20e-9 nfin=6
mp4 cout a net19 vdd! pmos_rvt w=162e-9 l=20e-9 nfin=6
mp3 net3 b vdd! vdd! pmos_rvt w=162e-9 l=20e-9 nfin=6
mp2 net3 a vdd! vdd! pmos_rvt w=162e-9 l=20e-9 nfin=6
mp0 cout cin net3 vdd! pmos_rvt w=162e-9 l=20e-9 nfin=6
mn23 net64 b vss! vss! nmos_rvt w=162e-9 l=20e-9 nfin=6
mn22 net74 a net64 vss! nmos_rvt w=162e-9 l=20e-9 nfin=6
mn21 s cin net74 vss! nmos_rvt w=162e-9 l=20e-9 nfin=6
mn17 net59 cin vss! vss! nmos_rvt w=108e-9 l=20e-9 nfin=4
mn16 net59 b vss! vss! nmos_rvt w=108e-9 l=20e-9 nfin=4
mn15 net59 a vss! vss! nmos_rvt w=108e-9 l=20e-9 nfin=4
mn14 s cout net59 vss! nmos_rvt w=108e-9 l=20e-9 nfin=4
mn9 net35 b vss! vss! nmos_rvt w=108e-9 l=20e-9 nfin=4
mn8 cout a net35 vss! nmos_rvt w=108e-9 l=20e-9 nfin=4
mn7 net7 a vss! vss! nmos_rvt w=108e-9 l=20e-9 nfin=4
mn6 net7 b vss! vss! nmos_rvt w=108e-9 l=20e-9 nfin=4
mn1 cout cin net7 vss! nmos_rvt w=108e-9 l=20e-9 nfin=4
