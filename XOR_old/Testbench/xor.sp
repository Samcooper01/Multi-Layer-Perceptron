mp12 net1 a vdd! vdd! pmos_rvt w=81e-9 l=20e-9 nfin=3
mp10 net27 b vdd! vdd! pmos_rvt w=81e-9 l=20e-9 nfin=3
mp5 out net27 net4 vdd! pmos_rvt w=162e-9 l=20e-9 nfin=3
mp2 net4 b vdd! vdd! pmos_rvt w=162e-9 l=20e-9 nfin=3
mp1 net4 a vdd! vdd! pmos_rvt w=162e-9 l=20e-9 nfin=3
mp0 out net1 net4 vdd! pmos_rvt w=162e-9 l=20e-9 nfin=3
mn15 net1 a vss! vss! nmos_rvt w=54e-9 l=20e-9 nfin=3
mn14 vss! b net27 vss! nmos_rvt w=54e-9 l=20e-9 nfin=3
mn9 net24 net27 vss! vss! nmos_rvt w=108e-9 l=20e-9 nfin=3
mn8 out net1 net24 vss! nmos_rvt w=108e-9 l=20e-9 nfin=3
mn4 net16 b vss! vss! nmos_rvt w=108e-9 l=20e-9 nfin=3
mn3 out a net16 vss! nmos_rvt w=108e-9 l=20e-9 nfin=3
